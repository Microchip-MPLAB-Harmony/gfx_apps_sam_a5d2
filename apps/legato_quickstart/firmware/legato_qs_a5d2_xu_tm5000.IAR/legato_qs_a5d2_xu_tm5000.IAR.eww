<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\legato_qs_a5d2_xu_tm5000.IAR.ewp</path>
    </project>
</workspace>
